
PACKAGECONFIG = " \
    binfmt \
    gshadow \
    hostnamed \
    kmod \
    logind \
    networkd \
    nss \
    nss-resolve \
    resolved \
    sysusers \
    timesyncd \
    zstd \
"
